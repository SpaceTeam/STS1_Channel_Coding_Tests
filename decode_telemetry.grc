options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Decoder for the QUBIK 1 & 2 satellites
    generate_options: no_gui
    id: satnogs_qubik_telem
    output_language: python
    run_options: run
    title: satnogs_qubik_telem
  states: {}

blocks:
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: (128+32+4)*8
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, -109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: NONE
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'False'
    frame_len: '255'
    preamble: '[0x33]*4'
    preamble_thrsh: '12'
    rs: 'True'
    sync_thrsh: '3'
    sync_word: '[0x3C, 0x67, 0x49, 0x52]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_cc
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    comment: |-
      Allow more wrong bits on the sync word,
       for the Viterbi paths to settle
    crc_type: NONE
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'False'
    frame_len: '255'
    preamble: '[0x33]*4'
    preamble_thrsh: '12'
    rs: 'True'
    sync_thrsh: '7'
    sync_word: '[0x3C, 0x67, 0x49, 0x52]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/2
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/input.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(math.pi*1.1)
    type: float
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_cc
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: '''{"Coding":"RS"}'''
  states: {}
- name: satnogs_json_converter_0_0
  id: satnogs_json_converter
  parameters:
    extra: '''{"Coding":"CC-RS"}'''
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:16887
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_file_source_0, '0', satnogs_frame_decoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [fec_extended_decoder_0, '0', satnogs_frame_decoder_0_0, '0']
- [satnogs_frame_decoder_0, out, satnogs_json_converter_0, in]
- [satnogs_frame_decoder_0_0, out, satnogs_json_converter_0_0, in]
- [satnogs_json_converter_0, out, blocks_message_debug_0, log]
- [satnogs_json_converter_0, out, zeromq_pub_msg_sink_0, in]
- [satnogs_json_converter_0_0, out, blocks_message_debug_0, log]
- [satnogs_json_converter_0_0, out, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
