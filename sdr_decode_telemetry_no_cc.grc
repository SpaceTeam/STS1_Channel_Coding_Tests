options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Decoder for the QUBIK 1 & 2 satellites
    generate_options: qt_gui
    id: satnogs_qubik_telem
    output_language: python
    run_options: run
    title: satnogs_qubik_telem
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '437395000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-lo_offset'
    sample_rate: samp_rate_rx
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * baudrate * 2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate_rx
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '8'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: baudrate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_rx//decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: satellites_ccsds_rs_deframer_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baudrate
    iq: 'True'
    samp_rate: samp_rate_rx//decimation
    subaudio: 'False'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: rx_freq-lo_offset
    gain: '32'
    samp_rate: samp_rate_rx
    type: fc32
    vga: '30'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_freq
    gain: '25'
    samp_rate: samp_rate_rx
    type: fc32
  states: {state: disabled}

connections:
- [blocks_freqshift_cc_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0, '0', satellites_fsk_demodulator_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_rs_deframer_0, out, blocks_message_debug_0, print]
- [satellites_ccsds_rs_deframer_0, out, pdu_pdu_to_stream_x_0, pdus]
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ccsds_rs_deframer_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', satellites_fsk_demodulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
