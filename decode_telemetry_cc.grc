options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Decoder for the QUBIK 1 & 2 satellites
    generate_options: no_gui
    id: satnogs_qubik_telem
    output_language: python
    run_options: run
    title: satnogs_qubik_telem
  states: {}

blocks:
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/input.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '8'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_stream_x_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
