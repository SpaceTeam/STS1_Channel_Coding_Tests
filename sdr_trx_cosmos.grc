options:
  parameters:
    description: TRX for STS1 Cubesat
    generate_options: no_gui
    id: sts1_trx_cosmos
    output_language: python
    run_options: run
    title: sts1_trx_cosmos
  states: {}

blocks:
- name: cosmos_ip
  id: variable
  parameters:
    value: '"10.99.97.43"'
  states: {}
- name: cosmos_mtu
  id: variable
  parameters:
    value: '1400'
  states: {}
- name: cosmos_port
  id: variable
  parameters:
    value: '"52001"'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '256'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '437395000'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: rx_baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rx_baudrate_beacon
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: tx_pre_switch_time
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/2
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/input.bin
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: lo_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-lo_offset'
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samp_rate//tx_baudrate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * rx_baudrate_beacon * 2
    decim: decimation*8
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_baudrate_beacon / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * rx_baudrate * 2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_baudrate / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: cosmos_ip
    mtu: cosmos_mtu
    port: cosmos_port
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    mtu: cosmos_mtu
    port: cosmos_port
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.concatenate((np.asarray([0x00]*int(tx_baudrate * tx_pre_switch_time / 8), np.uint8), np.asarray([0x55, 0x55, 0x55, 0x55, 0x1A, 0xCF, 0xFC, 0x1D], np.uint8),x))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_0_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.cons(pmt.PMT_NIL,pmt.to_pmt(np.concatenate((np.asarray([pmt.to_uint64(pmt.dict_ref(pmt.car(x), pmt.intern("baudrate"), pmt.PMT_NIL)), pmt.to_uint64(pmt.dict_ref(pmt.car(x), pmt.intern("rs_errors"), pmt.PMT_NIL))], np.uint64).byteswap().view(dtype=np.uint8),pmt.to_python(pmt.cdr(x))))))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("baudrate")
    v: pmt.from_uint64(rx_baudrate_beacon)
  states: {}
- name: pdu_pdu_set_0_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("baudrate")
    v: pmt.from_uint64(rx_baudrate)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX Demod"'
    size: '1024'
    srate: rx_baudrate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//decimation
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: complex
  states: {state: disabled}
- name: satellites_ccsds_rs_deframer_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}
- name: satellites_ccsds_rs_deframer_0_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '1'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_baudrate_beacon
    iq: 'True'
    samp_rate: samp_rate//(decimation*8)
    subaudio: 'False'
  states: {}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_baudrate
    iq: 'True'
    samp_rate: samp_rate//decimation
    subaudio: 'False'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq-lo_offset
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq-lo_offset
    gain: '0'
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', satellites_ccsds_rs_deframer_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0_0, '0', satellites_fsk_demodulator_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [network_socket_pdu_1_0, pdus, satellites_encode_rs_ccsds_0, in]
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_0_0, pdu, network_socket_pdu_1, pdus]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_0, pdus, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_set_0_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_0_0, pdus, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [satellites_ccsds_rs_deframer_0, out, pdu_pdu_set_0, pdus]
- [satellites_ccsds_rs_deframer_0_0, out, pdu_pdu_set_0_0, pdus]
- [satellites_encode_rs_ccsds_0, out, pdu_pdu_lambda_0, pdu]
- [satellites_fsk_demodulator_0, '0', satellites_ccsds_rs_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ccsds_rs_deframer_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
