options:
  parameters:
    description: TRX for STS1 Cubesat
    generate_options: no_gui
    id: sts1_trx_cosmos
    output_language: python
    run_options: run
    title: sts1_trx_cosmos
  states: {}

blocks:
- name: cosmos_ip
  id: variable
  parameters:
    value: '"10.99.97.49"'
  states: {}
- name: cosmos_mtu
  id: variable
  parameters:
    value: '1400'
  states: {}
- name: cosmos_port
  id: variable
  parameters:
    value: '"52001"'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '256'
  states: {}
- name: decimation_beacon
  id: variable
  parameters:
    value: 256*8
  states: {}
- name: freq
  id: variable
  parameters:
    value: '437395000'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rx_baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: rx_baudrate_beacon
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: tx_post_flush_bytes
  id: variable
  parameters:
    value: '192'
  states: {}
- name: tx_pre_switch_time
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/2
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/input.bin
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: lo_offset
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-lo_offset'
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samp_rate//tx_baudrate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * rx_baudrate_beacon * 2
    decim: decimation_beacon
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_baudrate_beacon / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * rx_baudrate * 2
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: rx_baudrate / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: cosmos_ip
    mtu: cosmos_mtu
    port: cosmos_port
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    mtu: cosmos_mtu
    port: cosmos_port
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.concatenate((np.asarray([0x00]*int(tx_baudrate * tx_pre_switch_time / 8), np.uint8), np.asarray([0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x1A, 0xCF, 0xFC, 0x1D], np.uint8),x,np.asarray([0x00]*int(tx_post_flush_bytes), np.uint8)))'
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_lambda_0_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.cons(pmt.PMT_NIL,pmt.to_pmt(np.concatenate((np.asarray([pmt.to_uint64(pmt.dict_ref(pmt.car(x), pmt.intern("baudrate"), pmt.PMT_NIL)), pmt.to_uint64(pmt.dict_ref(pmt.car(x), pmt.intern("rs_errors"), pmt.PMT_NIL))], np.uint64).byteswap().view(dtype=np.uint8),pmt.to_python(pmt.cdr(x))))))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("baudrate")
    v: pmt.from_uint64(rx_baudrate_beacon)
  states: {}
- name: pdu_pdu_set_0_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("baudrate")
    v: pmt.from_uint64(rx_baudrate)
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '1024'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX Demod"'
    size: '1024'
    srate: rx_baudrate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//decimation
    fc: '0'
    fftsize: '1024'
    name: '"RX"'
    type: complex
  states: {state: disabled}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '7'
  states: {}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '1'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_baudrate_beacon
    iq: 'True'
    samp_rate: samp_rate//decimation_beacon
    subaudio: 'False'
  states: {}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: rx_baudrate
    iq: 'True'
    samp_rate: samp_rate//decimation
    subaudio: 'False'
  states: {}
- name: satellites_pdu_scrambler_0
  id: satellites_pdu_scrambler
  parameters:
    sequence: '[0xff, 0x39, 0x9e, 0x5a, 0x68, 0xe9, 0x06, 0xf5, 0x6c, 0x89, 0x2f, 0xa1, 0x31, 0x5e, 0x08, 0xc0, 0x52, 0xa8, 0xbb, 0xae, 0x4e, 0xc2, 0xc7, 0xed, 0x66, 0xdc, 0x38, 0xd4, 0xf8, 0x86, 0x50, 0x3d, 0xfe, 0x73, 0x3c, 0xb4, 0xd1, 0xd2, 0x0d, 0xea, 0xd9, 0x12, 0x5f, 0x42, 0x62, 0xbc, 0x11, 0x80, 0xa5, 0x51, 0x77, 0x5c, 0x9d, 0x85, 0x8f, 0xda, 0xcd, 0xb8, 0x71, 0xa9, 0xf1, 0x0c, 0xa0, 0x7b, 0xfc, 0xe6, 0x79, 0x69, 0xa3, 0xa4, 0x1b, 0xd5, 0xb2, 0x24, 0xbe, 0x84, 0xc5, 0x78, 0x23, 0x01, 0x4a, 0xa2, 0xee, 0xb9, 0x3b, 0x0b, 0x1f, 0xb5, 0x9b, 0x70, 0xe3, 0x53, 0xe2, 0x19, 0x40, 0xf7, 0xf9, 0xcc, 0xf2, 0xd3, 0x47, 0x48, 0x37, 0xab, 0x64, 0x49, 0x7d, 0x09, 0x8a, 0xf0, 0x46, 0x02, 0x95, 0x45, 0xdd, 0x72, 0x76, 0x16, 0x3f, 0x6b, 0x36, 0xe1, 0xc6, 0xa7, 0xc4, 0x32, 0x81, 0xef, 0xf3, 0x99, 0xe5, 0xa6, 0x8e, 0x90, 0x6f, 0x56, 0xc8, 0x92, 0xfa, 0x13, 0x15, 0xe0, 0x8c, 0x05, 0x2a, 0x8b, 0xba, 0xe4, 0xec, 0x2c, 0x7e, 0xd6, 0x6d, 0xc3, 0x8d, 0x4f, 0x88, 0x65, 0x03, 0xdf, 0xe7, 0x33, 0xcb, 0x4d, 0x1d, 0x20, 0xde, 0xad, 0x91, 0x25, 0xf4, 0x26, 0x2b, 0xc1, 0x18, 0x0a, 0x55, 0x17, 0x75, 0xc9, 0xd8, 0x58, 0xfd, 0xac, 0xdb, 0x87, 0x1a, 0x9f, 0x10, 0xca, 0x07, 0xbf, 0xce, 0x67, 0x96, 0x9a, 0x3a, 0x41, 0xbd, 0x5b, 0x22, 0x4b, 0xe8, 0x4c, 0x57, 0x82, 0x30, 0x14, 0xaa, 0x2e, 0xeb, 0x93, 0xb0, 0xb1, 0xfb, 0x59, 0xb7, 0x0e, 0x35, 0x3e, 0x21, 0x94, 0x0f, 0x7f, 0x9c, 0xcf, 0x2d, 0x34, 0x74, 0x83, 0x7a, 0xb6, 0x44, 0x97, 0xd0, 0x98, 0xaf, 0x04, 0x60, 0x29, 0x54, 0x5d, 0xd7, 0x27, 0x61, 0x63, 0xf6, 0xb3, 0x6e, 0x1c, 0x6a, 0x7c, 0x43, 0x28, 0x1e]'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq-lo_offset
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq-lo_offset
    gain: '0'
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0_0, '0', satellites_fsk_demodulator_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [network_socket_pdu_1_0, pdus, satellites_encode_rs_ccsds_0, in]
- [pdu_pdu_lambda_0, pdu, blocks_message_debug_0, print]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_lambda_0_0, pdu, network_socket_pdu_1, pdus]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_0, pdus, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_set_0_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_0_0, pdus, pdu_pdu_lambda_0_0, pdu]
- [pdu_pdu_to_stream_x_0, '0', digital_gmsk_mod_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_set_0, pdus]
- [satellites_ccsds_concatenated_deframer_0_0, out, pdu_pdu_set_0_0, pdus]
- [satellites_encode_rs_ccsds_0, out, satellites_pdu_scrambler_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [satellites_pdu_scrambler_0, out, pdu_pdu_lambda_0, pdu]
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
