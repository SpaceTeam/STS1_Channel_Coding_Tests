options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Decoder for the QUBIK 1 & 2 satellites
    generate_options: qt_gui
    id: satnogs_qubik_telem
    output_language: python
    run_options: run
    title: satnogs_qubik_telem
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '437395000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/input.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: lo_offset
    sample_rate: samp_rate_rx
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samp_rate_rx//baudrate
  states: {}
- name: digital_gmskmod_bc_0
  id: digital_gmskmod_bc
  parameters:
    L: '4'
    bt: '0.3'
    samples_per_symbol: samp_rate_rx//baudrate
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: rx_freq-lo_offset
    samp_rate: samp_rate_rx
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_file_source_0, '0', digital_gmskmod_bc_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', soapy_hackrf_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_freqshift_cc_0, '0']
- [digital_gmskmod_bc_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
