options:
  parameters:
    generate_options: qt_gui
    id: sdr_decode_telemetry_no_cc_gr_satnogs
    output_language: python
    run_options: run
    title: sdr_decode_telemetry_no_cc_gr-satnogs
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '437395000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: NONE
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'False'
    frame_len: '255'
    preamble: '[]'
    preamble_thrsh: '0'
    rs: DUAL_BASIS
    sync_thrsh: '4'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_1
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc_type: NONE
    custom_crc: satnogs.crc.crc16(0x1021, 0xFFFF, 0xFFFF, True, True)
    drop_invalid: 'False'
    frame_len: '255'
    preamble: '[]'
    preamble_thrsh: '0'
    rs: DUAL_BASIS
    sync_thrsh: '4'
    sync_word: '[0x1A, 0xCF, 0xFC, 0x1D]'
    var_len: 'False'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_rigctl
  id: variable
  parameters:
    value: satnogs.dummy_doppler_correction.make(rx_freq)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.2 * (samples_per_symbol//2)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/dump_iq.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/dump_iq.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_rx
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: 0.175 * 2
    gain_omega: 2 * math.pi / 100 * 4
    mu: '0.5'
    omega: samples_per_symbol*8
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: 2*4
    sensitivity: '1'
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.005'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: samples_per_symbol
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: 2 * math.pi / 100
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_symbol*8
    ted_gain: '1'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * baudrate
    decim: decimation //samples_per_symbol
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: baudrate*1.25
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 2.0
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '8'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,2,1
    label1: Freq
    name: '"FSK Constellation"'
    size: '102'
    type: complex
    xmax: '1.1'
    xmin: '-1.1'
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: baudrate *(samples_per_symbol//2)*8
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha5: '0.5'
    autoscale: 'True'
    grid: 'True'
    label1: out
    label2: error
    label3: T_inst
    label4: T_avg
    label5: bits
    marker5: '0'
    name: '"out"'
    nconnections: '5'
    size: '102400'
    srate: baudrate *(samples_per_symbol//2)
    style5: '3'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: data
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baudrate*decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.001'
    gain: '8'
    interp: '8'
    ntaps: '1024'
    samp_rate: baudrate*samples_per_symbol
    sym_rate: baudrate
    type: interp_fir_filter_fff
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    doppler_src: variable_rigctl
    lo_offset: lo_offset
    out_samp_rate: baudrate*decimation
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_1
    itype: byte
    vlen: '1'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: rx_freq-lo_offset
    gain: '32'
    samp_rate: samp_rate_rx
    type: fc32
    vga: '30'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', dc_blocker_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_1, '4']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', satnogs_doppler_compensation_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_gfsk_demod_0, '0', satnogs_frame_decoder_0, '0']
- [digital_gmsk_demod_0, '0', satnogs_frame_decoder_0, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_0_0, '1', qtgui_time_sink_x_0_0_1, '1']
- [digital_symbol_sync_xx_0_0, '2', qtgui_time_sink_x_0_0_1, '2']
- [digital_symbol_sync_xx_0_0, '3', qtgui_time_sink_x_0_0_1, '3']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [satnogs_doppler_compensation_0, '0', blocks_delay_0, '0']
- [satnogs_doppler_compensation_0, '0', low_pass_filter_0_0_0, '0']
- [satnogs_frame_decoder_0, out, blocks_message_debug_0, print]
- [satnogs_frame_decoder_0, out, pdu_pdu_to_stream_x_0, pdus]
- [soapy_hackrf_source_0, '0', blocks_file_sink_1, '0']
- [soapy_hackrf_source_0, '0', satnogs_doppler_compensation_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
